# Keil uVision project 串口读取8266时间显示oled.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: oled显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware;.\system
  group Source Group 1
    ./: main.c
    ./hardware/: tm1638.c tm1638.h f6x8.h ssd1306.c ssd1306.h iic.c iic.h
    ./system/: delay.c delay.h public.c public.h uart.c uart.h
